# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Project +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: SROS/source, .
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Startup
    ./: LPC2300.s
  group ?
    ./: isr.cpp main.cpp isr.h memmutex.c
  group Serial
    ./serial/: Serial.cpp serial.h retarget.cpp
  group LCD
    ./lcd/: LCD_4bit.cpp LCD.h
  group LED
    ./LED/: led.cpp
  group Timer
    ./: timer.cpp timer.h
  group Network
    ./network/: ethernet.h EMAC.h
  group SROS
    ./SROS/source/: mutexObject.c rtos.c mailboxObjectAsm.s mutexObjectAsm.s rtos.h rtosAsm.h rtosAsm.s rtosImpl.h semaphoreObjectAsm.s typeDef.h rwLock.c rwLock.h
  group SROS++
    ./SROSpp/: ethernet.hpp mailbox.hpp threadfactory.hpp semaphore.hpp arp.hpp driver.hpp ethernet_driver.hpp ethernet_driver_lpc23xx.hpp ethernet_handler.hpp irq_handler.hpp arp_cache.hpp arp_handler.hpp ip.hpp ll.hpp
